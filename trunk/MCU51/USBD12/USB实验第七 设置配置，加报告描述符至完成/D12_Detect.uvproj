# Keil uVision project D12_Detect.uvproj, settings and files
target D12Detect (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: D12_Detect +hex
  c flags: Optimize=8 SizeSpeed=1
  group default
    ./: key.c main.c uart.c D12.c usbCore.c
