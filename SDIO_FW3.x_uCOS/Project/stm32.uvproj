# Keil uVision project stm32.uvproj, settings and files
target stm32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32 +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_HD
  c include: ..\FWLIB\inc;..\Source;..\CMSIS;..\uCOS-II\uCOS-II-V290;..\uCOS-II\Port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group Source
    ../Source/: main.c stm32f10x_it.c system.h
  group sdio
    ../sdio/: sdcard.c
  group filesystem
    ../filesystem/: diskio.c ff.c
  group uC/OS-II
    ../uCOS-II/Port/: os_cpu_c.c os_dbg.c os_cpu_a.s
    ../uCOS-II/uCOS-II-V290/: ucos_ii.c
  group 5110
    ../5110/: delay.c enpix.c lcd.c spi.c
  group motor
    ../motor/: stepmotor.c
  group usart
    ../uart/: usart.c
